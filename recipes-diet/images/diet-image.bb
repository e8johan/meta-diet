require recipes-core/images/core-image-minimal.bb

IMAGE_INSTALL += "systemd-analyze"